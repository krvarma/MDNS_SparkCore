// This #include statement was automatically added by the Spark IDE.
#include "MDNS/mdns.h"

#define LISTEN_PORT 7

TCPServer echoServer(LISTEN_PORT);
MDNSResponder mdns;

char szIP[64];
bool isStarted;
char szHTML[] = "<html><body><p>Spark Core and MDNS Working :)</p></body></html>";

TCPServer server = TCPServer(80);

void setup() {
    // Retrieve and convert to integer format
    IPAddress addr = Network.localIP();
    uint32_t ip = (addr[0] * 16777216) + (addr[1] * 65536) + (addr[2] * 256) + (addr[3]);
    
    // Begin MDNS
    isStarted = mdns.begin("myspark", ip);
    
    // If started, set the variable to IP address of the Spark Core
    // else set error message
    if(isStarted){
        sprintf(szIP, "%d.%d.%d.%d (%u)", addr[0], addr[1], addr[2], addr[3], ip);
         server.begin();
    }
    else{
        sprintf(szIP, "Error starting MDNS.");
    }
    
    Spark.variable("mdnsstatus", szIP, STRING);
}

void loop() {
    // If we started successfully, then wait for the client to connect
    // else do nothing
    if(isStarted){
        TCPClient client = server.available();
        if (client){
            client.write(szHTML);
            client.flush();
            client.stop();
        }
    }
    
    delay(2000);
}